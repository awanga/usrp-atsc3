options:
  parameters:
    author: gr-atsc3
    comment: |-
      ATSC 3.0 Software-Defined Receiver
      For use with USRP N2x0 + TVRX daughterboard
    description: Complete ATSC 3.0 physical layer receiver
    generate_options: qt_gui
    id: atsc3_rx
    output_language: python
    title: ATSC 3.0 Receiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency (MHz)
    start: '473'
    step: '6'
    stop: '803'
    value: '617'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.144e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: cp_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: pilot_pattern
  id: variable
  parameters:
    value: '3'
  states: {}
- name: modulation
  id: variable
  parameters:
    comment: 0=QPSK, 1=16QAM, 2=64QAM, 3=256QAM
    value: '2'
  states: {}
- name: code_rate
  id: variable
  parameters:
    comment: 0=2/15 to 11=13/15
    value: '6'
  states: {}
- name: ti_mode
  id: variable
  parameters:
    comment: 0=None, 1=CTI, 2=HTI
    value: '1'
  states: {}
- name: plp_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: center_freq * 1e6
    clock_rate: 100e6
    comment: |-
      USRP N2x0 + TVRX Daughterboard
      Default IP: 192.168.10.2
      Uses PC clock for timing
    dc_offs_enb0: 'True'
    dev_addr: '"type=usrp2,addr=192.168.10.2"'
    gain0: rf_gain
    iq_imbal_enb0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: atsc3_bootstrap_detect_0
  id: atsc3_bootstrap_detect
  parameters:
    threshold: '0.7'
  states: {}
- name: atsc3_ofdm_demod_0
  id: atsc3_ofdm_demod
  parameters:
    cp_length: cp_length
    fft_size: fft_size
  states: {}
- name: atsc3_channel_eq_0
  id: atsc3_channel_eq
  parameters:
    fft_size: fft_size
    pilot_pattern: pilot_pattern
    use_mmse: 'True'
  states: {}
- name: atsc3_constellation_demapper_0
  id: atsc3_constellation_demapper
  parameters:
    code_rate: code_rate
    modulation: modulation
    noise_variance: '0.1'
  states: {}
- name: atsc3_cell_deinterleaver_0
  id: atsc3_cell_deinterleaver
  parameters:
    fft_size: fft_size
  states: {}
- name: atsc3_freq_deinterleaver_0
  id: atsc3_freq_deinterleaver
  parameters:
    fft_size: fft_size
  states: {}
- name: atsc3_time_deinterleaver_0
  id: atsc3_time_deinterleaver
  parameters:
    ti_depth: '0'
    ti_mode: ti_mode
  states: {}
- name: atsc3_fec_decode_0
  id: atsc3_fec_decode
  parameters:
    code_rate: code_rate
    codeword_length: '64800'
    max_iterations: '50'
  states: {}
- name: atsc3_alp_demux_0
  id: atsc3_alp_demux
  parameters:
    plp_id: plp_id
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      ALP packet output
      (IP/MPEG-TS data)
    file: /tmp/atsc3_alp_packets.bin
    type: byte
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: Input Spectrum
    name: '"RF Input Spectrum"'
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_const_sink_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Equalized
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', atsc3_bootstrap_detect_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_0, '0']
- [atsc3_bootstrap_detect_0, '0', atsc3_ofdm_demod_0, '0']
- [atsc3_ofdm_demod_0, '0', atsc3_channel_eq_0, '0']
- [atsc3_channel_eq_0, '0', qtgui_const_sink_0, '0']
- [atsc3_channel_eq_0, '0', atsc3_constellation_demapper_0, '0']
- [atsc3_constellation_demapper_0, '0', atsc3_cell_deinterleaver_0, '0']
- [atsc3_cell_deinterleaver_0, '0', atsc3_freq_deinterleaver_0, '0']
- [atsc3_freq_deinterleaver_0, '0', atsc3_time_deinterleaver_0, '0']
- [atsc3_time_deinterleaver_0, '0', atsc3_fec_decode_0, '0']
- [atsc3_fec_decode_0, '0', atsc3_alp_demux_0, '0']
- [atsc3_alp_demux_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
